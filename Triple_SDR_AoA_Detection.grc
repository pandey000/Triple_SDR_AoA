options:
  parameters:
    author: Pandey
    generate_options: qt_gui
    id: Triple_Sdr_AoA_Detection
    output_language: python
    title: Triple_Sdr_AoA_Detection
  states: {}

blocks:
- name: freq_aoa
  id: variable
  parameters:
    value: 2.442e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15e6
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt

      class freq_controller(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name='3-Channel Controller', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_message)
              self._parent = None 

          def set_parent(self, parent):
              self._parent = parent

          def handle_message(self, msg):
              try:
                  # We expect a message format: "channel_index:frequency"
                  # Example: "2:2442000000.0"
                  msg_str = pmt.symbol_to_string(msg)
                  parts = msg_str.split(':')
                  
                  chan_idx = int(parts[0])
                  new_freq = float(parts[1])
                  
                  if self._parent is not None:
                      # Direct call to the multi-channel setter
                      self._parent.osmosdr_source_0.set_center_freq(new_freq, chan_idx)
                      print(f"[GRC] Radio {chan_idx} tuned to {new_freq/1e6} MHz")
                  else:
                      print("[GRC] Error: Controller not linked to parent flowgraph.")

              except Exception as e:
                  print(f"[GRC] Control Error: {e}")

          def work(self, input_items, output_items):
              return 0
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '8192'
    port: '50000'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '8192'
    port: '50002'
    send_eof: 'False'
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=000000000000000000a063dc30282397 hackrf=0000000000000000849860c82f8a56d7 hackrf=000000000000000060a464dc3611620f
    bb_gain0: '12'
    bb_gain1: '12'
    bb_gain2: '12'
    clock_source0: internal
    clock_source1: external
    clock_source2: external
    corr1: '0'
    corr2: '0'
    dc_offset_mode0: '2'
    dc_offset_mode1: '2'
    dc_offset_mode2: '2'
    freq0: freq_aoa
    freq1: freq_aoa
    freq2: freq_aoa
    gain0: '0'
    gain1: '0'
    gain2: '0'
    gain_mode0: 'False'
    gain_mode1: 'False'
    gain_mode2: 'False'
    if_gain0: '8'
    if_gain1: '8'
    if_gain2: '8'
    iq_balance_mode1: '0'
    iq_balance_mode2: '0'
    nchan: '3'
    num_mboards: '3'
    sample_rate: samp_rate
    sync: sync
    time_source1: external
    time_source2: external
    type: fc32
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: self.epy_block_0.set_parent(self)
    section: main_after_init
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:60000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:60002
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:60001
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:50005
    bind: 'True'
    timeout: '100'
  states: {}

connections:
- [osmosdr_source_0, '0', network_udp_sink_0, '0']
- [osmosdr_source_0, '0', zeromq_pub_sink_0, '0']
- [osmosdr_source_0, '1', zeromq_pub_sink_0_0_0, '0']
- [osmosdr_source_0, '2', network_udp_sink_0_0, '0']
- [osmosdr_source_0, '2', zeromq_pub_sink_0_0, '0']
- [zeromq_pull_msg_source_0, out, epy_block_0, msg_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
